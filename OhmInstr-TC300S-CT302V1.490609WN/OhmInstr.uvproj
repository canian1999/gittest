# Keil uVision project OhmInstr.uvproj, settings and files
target OhmInstr (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OhmInstr +hex
  c flags: Optim=1 wLevel=2
  c include: C:\Keil\ARM\RV31\LIB\ST;..\OhmInstr-v121301-DTS201306151746
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s main.c stm32f10x_it.c system.c lcd2010.c key2010.c IIC.C ds18b20.c RTC.c adc.c yuyin.c spi.c sx1276_7_8.c
    C:/Keil/ARM/RV31/LIB/ST/: STM32F10xR.LIB
